# Keil uVision project Project.uvprojx, settings and files
target STM32L1XX_MD(STM32L1xxxBxx) (ARM-ADS)
  device: STM32L152RB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: output +hex
  AfterMake: fromelf.exe --bin -o ./Obj/output.bin  ./Obj/output.axf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32L1XX_MD
  c include: ..\User;..\Utility;..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\ST\STM32L1xx\Include;..\Libraries\STM32L1xx_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0x1d000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group User
    ../User/: main.c stm32l1xx_it.c
  group Utility
    ../Utility/: bsp_usart.c xprintf.c
  group StdPeriph_Driver
    ../Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c stm32l1xx_aes_util.c
  group CMSIS
    ../User/: system_stm32l1xx.c
  group MDK-ARM
    ../Libraries/CMSIS/Device/ST/STM32L1xx/Source/Templates/arm/: startup_stm32l1xx_md.s

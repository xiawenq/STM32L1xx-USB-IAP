# Keil uVision project DFU.uvprojx, settings and files
target STM32L152-EVAL (ARM-ADS)
  device: STM32L152RB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: output +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32L1XX_MD, USE_STM32L152_EVAL
  c include: ..\utility;..\User\inc;..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\ST\STM32L1xx\Include;..\Libraries\STM32_USB-FS-Device_Driver\inc;..\Libraries\STM32L1xx_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group User
    ../Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c
    ../User/src/: dfu_mal.c flash_if.c hw_config.c main.c usb_desc.c usb_istr.c usb_prop.c usb_pwr.c stm32_it.c
  group Utility
    ../utility/: bsp_usart.c xprintf.c
  group USB-FS-Device_Driver
    ../Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group STM32L1xx_StdPeriph_Driver
    ../Libraries/STM32L1xx_StdPeriph_Driver/src/: stm32l1xx_usart.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_gpio.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_syscfg.c stm32l1xx_dma.c
  group CMSIS
    ../User/src/: system_stm32l1xx.c
    ../Libraries/CMSIS/Device/ST/STM32L1xx/Source/Templates/arm/: startup_stm32l1xx_md.s
